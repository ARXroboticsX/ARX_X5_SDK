Commit message: 修改保护模式

File: master1/src/arm_control/models/ultron_v1.1_aa.urdf (robot description, URDF)
Before this commit: robot ultron_v1.1_aa, 7 links, 6 joints
Links:
- link link6: mass 0.640 -> 0.581000
